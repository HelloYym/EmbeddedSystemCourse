<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32-SK-OS-Probe-LCD-v5.ewp</path>
  </project>
  <batchBuild/>
</workspace>


