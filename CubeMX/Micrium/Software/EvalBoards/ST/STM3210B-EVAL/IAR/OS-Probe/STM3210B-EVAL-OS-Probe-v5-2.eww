<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM3210B-EVAL-OS-Probe-v5-2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


